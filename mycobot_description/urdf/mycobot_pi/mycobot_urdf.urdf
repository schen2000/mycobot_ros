Commit message: tmp disable g_base collision.

File: mycobot_description/urdf/mycobot_pi/mycobot_urdf.urdf (robot description, URDF)
Before this commit: robot firefighter, 8 links, 7 joints
Links:
- link g_base: geometry visual mesh filename=package://mycobot_description/urdf/mycobot_pi/G_base.dae
